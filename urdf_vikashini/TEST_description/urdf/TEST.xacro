Commit message: Update TEST.xacro

File: urdf_vikashini/TEST_description/urdf/TEST.xacro (robot description, xacro)
@@ -120,5 +120,5 @@
   <parent link="mount_1"/>
   <child link="lidar_1"/>
-  <axis xyz="-0.0 0.0 1.0"/>
+  <axis xyz="0.0 0.0 1.0"/>
 </joint>
 <joint name="Rigid4" type="fixed">
